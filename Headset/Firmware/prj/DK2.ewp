# IAR project DK2.ewp, settings and files
configuration REV3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L100xB ST STM32L100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; STM32L1XX; DK2_REV3; HSE_VALUE=12000000
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32L1xx\Include; ..\lib\STM32L\inc; ..\lib\CPAL\inc; ..\lib\CPAL\devices\stm32l1xx; ..\lib\USB\inc; ..\board\inc; ..\lib\Oculus\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DK2.bin
  ILINK.IlinkOutputFile: DK2.out
  ILINK.IlinkIcfFile: stm32l100xB_bootload.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration REV3-DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: DK2-Debug.bin
configuration REV3_3 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; STM32L1XX; DK2_REV3_3; HSE_VALUE=12000000
configuration REV3_3-DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: DK2-Debug.bin
  group Application
    ../src/: button.c debug.c display_info.c leds.c lens_distortion.c main.c manufacturing.c sequence.c shiftout.c startup_stm32l1xx_md.s stm32l.c stm32l1xx_it.c timestamper.c
  group Application/Calibration
    ../src/: autocalibrate.c averaging.c calibrate.c factory.c temperature.c
  group Application/Display
    ../src/: ams568.c edid.c gamma.c h2c.c panel.c s6e3fa0.c vsync.c
  group Application/Sensors
    ../src/: lis3mdl.c mpu6500.c
  group Application/USB
    ../src/: feature_report.c in_report.c report_helper.c usb.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Libraries/Board
    ../board/src/: hub.c
  group Libraries/CPAL
    ../lib/CPAL/src/: cpal_hal.c cpal_i2c.c cpal_usercallback.c
    ../lib/CPAL/devices/stm32l1xx/: cpal_i2c_hal_stm32l1xx.c
  group Libraries/Oculus
    ../lib/Oculus/src/: bootloader_state.c config.c crc.c delay.c eeprom.c gpio.c m24.c spi.c systick.c uuid.c
  group Libraries/STM32L
    ../lib/STM32L/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Libraries/USB
    ../lib/USB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
